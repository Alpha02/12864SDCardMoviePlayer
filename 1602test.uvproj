# Keil uVision project 1602test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 1602test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\【高能】60s2常见功能的顶级封装
  group Source Group 1
    ./: main.c lcd12864.c lcd12864.h sakura1.h
    ../【高能】60s2常见功能的顶级封装/: comm.c comm.h serial.c serial.h keyBoard.c keyBoard.h ClowCards.h SD.c SD.h
